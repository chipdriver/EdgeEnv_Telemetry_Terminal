# Keil uVision project EdgeEnv_Telemetry_Terinal.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: EdgeEnv_Telemetry_Terinal
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F411xE
  c include: .\Lib\Libraries\STM32F4xx_StdPeriph_Driver\inc;.\Lib\Libraries\CMSIS\Include;.\Lib\Libraries\CMSIS\Device\ST\STM32F4xx\Include;.\User;.\User\App\Inc;.\User\BSP\Inc;.\User\Drivers\Inc;.\User\Services\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Startup
    ./Lib/Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f411xe.s
  group CMSIS
    ./Lib/Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group StdPeriph
    ./Lib/Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_sai.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_usart.c
  group User_BSP
    ./User/BSP/Src/: dht11_gpio.c tft_gpio.c i2c.c spi.c dwt_delay.c uart.c
  group User_Drivers
    ./User/Drivers/Src/: dht11_Drivers.c st7789.c font.c ST6336.c
  group User_Services
    ./User/Services/Src/: tp_event.c
  group User_APP
    ./User/App/Src/: stm32f4xx_it.c main.c
